# SPDX-FileCopyrightText: 2025 Margo
#
# SPDX-License-Identifier: MIT
#
# SPDX-FileContributor: Michael Adler <michael.adler@siemens.com>

FILESPATH:append := ":${FILE_DIRNAME}/files"

SRC_URI += "file://container.cfg"
